LIC_FILES_CHKSUM = "file://LICENSE;md5=b9257785fc4f3803a4b71b76c1412729"

SRCREV = "6988be3878661db9c1809e319adae1fd743a1835"

PV = "10.1.2"
PKGV = "10.1.2"
