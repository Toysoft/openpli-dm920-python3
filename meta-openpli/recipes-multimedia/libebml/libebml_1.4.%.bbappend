#Static library enabled by default. It has been added in case you want to use it dynamically.
EXTRA_OECMAKE = "-DBUILD_SHARED_LIBS=ON"
